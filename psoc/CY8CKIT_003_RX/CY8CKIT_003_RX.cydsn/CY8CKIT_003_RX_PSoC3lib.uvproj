# Keil uVision project CY8CKIT_003_RX_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: CY8CKIT_003_RX_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h LED_Control_Reg.c LED_Control_Reg.h LED_0.c LED_0.h LED_0_aliases.h LED_1.c LED_1.h LED_1_aliases.h LED_2.c LED_2.h LED_2_aliases.h LED_3.c LED_3.h LED_3_aliases.h LED_4.c LED_4.h LED_4_aliases.h LED_5.c LED_5.h LED_5_aliases.h LED_6.c LED_6.h LED_6_aliases.h LED_7.c LED_7.h LED_7_aliases.h MISO.c MISO.h MISO_aliases.h MOSI.c MOSI.h MOSI_aliases.h SCLK.c SCLK.h SCLK_aliases.h RadioController.c RadioController.h RadioController_PM.c RadioController_INT.c SS.c SS.h SS_aliases.h Button.c Button.h Button_aliases.h LCD.c LCD.h LCD_PM.c RadioController_IntClock.c RadioController_IntClock.h LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: CY8CKIT_003_RX_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU CASE
